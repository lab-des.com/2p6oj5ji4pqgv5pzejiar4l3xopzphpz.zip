Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-04-06T17:50:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 06 17:50:56 2023 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\745c35c8-9d48-435b-bf5f-9177c9d63d3c\90e0b794-cd4e-4fd4-be5b-9c927a7854ad\ifc * Database version: 5507 * Database creation date: Thu Apr 06 17:50:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 06 17:50:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 06 17:50:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Joyn 2 Touchdown, Vitra-Joyn_2-Touchdown_rfa:Joyn 2 Touchdown:506806
In: Level 1
Type - Material: 01 basic dark, Table powder coating soft light
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Joyn_2-Touchdown_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office tables; NBSReference: 45-35-20/340; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_60; Uniclass2015Description: Office tables; Uniclass2015Reference: Pr_40_50_21_60; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Joyn 2 Touchdown; Cost: 0; Designer: Ronan & Erwan Bouroullec, 2023; Manufacturer: Vitra; Model: Joyn 2 Touchdown; OmniClass Number: 23.40.20.14.17; OmniClass Title: Residential Tables and Cabinets; Type Name: Joyn 2 Touchdown; URL: https://www.vitra.com/en-un/office/product/details/joyn-2-touchdown
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Joyn_2-Touchdown_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Melanine & metal; ModelNumber: n/a; ModelReference: n/a; Name: Joyn_2-Touchdown_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 1200-3200x1400-1800x740/1100 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Joyn_2-Touchdown_rfa; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Joyn 2 Touchdown
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - CoverControl: no; DepthControl: 1400 mm; Elevation from Level: 0 mm; HeightControl: 740 mm; Host: Level : Level 1; LegTypeLeftEdgeControl: yes; LegTypeRightEdgeControl: yes; LegTypeWheelsControl: no; LegVisibilityLeft: yes; LegVisibilityRight: yes; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; WidthControl: 2000 mm
Dimensions - Area: 5.316 m2; NominalDepth: 1400 mm; NominalHeight: 740 mm; NominalLength: 2000 mm; Volume: 2.072 m3
Materials and Finishes - CoverMaterial: 04 white; SurfaceMaterial: 01 basic dark; TableTopMaterial: Table powder coating soft light
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Joyn_2-Touchdown_rfa: Joyn 2 Touchdown; Family and Type: Vitra-Joyn_2-Touchdown_rfa: Joyn 2 Touchdown; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Joyn_2-Touchdown_rfa: Joyn 2 Touchdown; Type Id: Vitra-Joyn_2-Touchdown_rfa: Joyn 2 Touchdown; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
